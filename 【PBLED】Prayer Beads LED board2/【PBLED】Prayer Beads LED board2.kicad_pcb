# Repository Natyosu-Natyosu/kicad_LED

## KiCad design 【PBLED】Prayer Beads LED board2/【PBLED】Prayer Beads LED board2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: C; C_seramic_SMD
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J33, J34, J35, J36, J37, J38, J39, J40, J41, J42, J43, J44, J45, J46, J47, J48, J49, J50, J51, J52, J53, J54, J55, J56, J57, J58, J59, J60, J61, J62, J63, J64, J65: PinSocket_1x01_Vertical
J32: PinSocket_1x08_Vertical
P1: Digital; Socket_Strip_Arduino_1x15
P2: Analog; Socket_Strip_Arduino_1x15
P3, P4, P5, P6: CONN_01X01; 1pin_Nano
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: AO3400A; SOT95P280X125-3N; PARTREV L
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64: R220Ω; R_SMD
U1, U2, U3, U4, U5, U6, U7, U8: LOGIC-74HC595D(SOIC16); SOIC16-1.27-10X3.9MM; MPN 74HC595D
U9: USB-C; USB_C

Connections:
+5V: C2.2, C5.2, C8.2, C11.2, C14.2, C17.2, C20.2, C23.2, P2.4, U1.10 (SCL), U1.16 (VCC), U2.10 (SCL), U2.16 (VCC), U3.10 (SCL), U3.16 (VCC), U4.10 (SCL), U4.16 (VCC), U5.10 (SCL), U5.16 (VCC), U6.10 (SCL), U6.16 (VCC), U7.10 (SCL), U7.16 (VCC), U8.10 (SCL), U8.16 (VCC), U9.A9 (VBUS), U9.B9 (VBUS)
/0(Rx): P1.2
/1(Tx): P1.1
/2: C1.2, C4.2, C7.2, C10.2, C13.2, C16.2, C19.2, C22.2, P1.5, U1.12 (RCK), U2.12 (RCK), U3.12 (RCK), U4.12 (RCK), U5.12 (RCK), U6.12 (RCK), U7.12 (RCK), U8.12 (RCK)
/3(**): C3.2, C6.2, C9.2, C12.2, C15.2, C18.2, C21.2, C24.2, P1.6, U1.11 (SCK), U2.11 (SCK), U3.11 (SCK), U4.11 (SCK), U5.11 (SCK), U6.11 (SCK), U7.11 (SCK), U8.11 (SCK)
/4: P1.7, U1.14 (SER)
/5(**): P1.8
/6(**): P1.9
/7: P1.10
/8: P1.11
/9(**): P1.12
/10(**/SS): P1.13
/11(**/MOSI): P1.14
/12(MISO): P1.15
/A0: P2.12, Q1.1
/A1: P2.11, Q2.1
/A2: P2.10, Q3.1
/A3: P2.9, Q4.1
/A4: P2.8, Q5.1
/A5: P2.7, Q6.1
/A6: P2.6, Q7.1
/A7: P2.5, Q8.1
/Reset: P1.3, P2.3
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, P1.4, P2.2, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, U1.8 (GND), U1.13 (G), U2.8 (GND), U2.13 (G), U3.8 (GND), U3.13 (G), U4.8 (GND), U4.13 (G), U5.8 (GND), U5.13 (G), U6.8 (GND), U6.13 (G), U7.8 (GND), U7.13 (G), U8.8 (GND), U8.13 (G), U9.A12 (GND), U9.B12 (GND), U9.S2
unnamed: J1.1, R1.1
unnamed: J2.1, R2.1
unnamed: J3.1, R3.1
unnamed: J4.1, R4.1
unnamed: J5.1, R5.1
unnamed: J6.1, R6.1
unnamed: J7.1, R7.1
unnamed: J8.1, R8.1
unnamed: J9.1, R9.1
unnamed: J10.1, R10.1
unnamed: J11.1, R11.1
unnamed: J12.1, R12.1
unnamed: J13.1, R13.1
unnamed: J14.1, R14.1
unnamed: J15.1, R15.1
unnamed: J16.1, R16.1
unnamed: J17.1, R17.1
unnamed: J18.1, R18.1
unnamed: J19.1, R19.1
unnamed: J20.1, R20.1
unnamed: J21.1, R21.1
unnamed: J22.1, R22.1
unnamed: J23.1, R23.1
unnamed: J24.1, R24.1
unnamed: J25.1, R25.1
unnamed: J26.1, R26.1
unnamed: J27.1, R27.1
unnamed: J28.1, R28.1
unnamed: J29.1, R29.1
unnamed: J30.1, R30.1
unnamed: J31.1, R31.1
unnamed: J32.1, Q1.3
unnamed: J32.2, Q2.3
unnamed: J32.3, Q3.3
unnamed: J32.4, Q4.3
unnamed: J32.5, Q5.3
unnamed: J32.6, Q6.3
unnamed: J32.7, Q7.3
unnamed: J32.8, Q8.3
unnamed: J33.1, R32.1
unnamed: J34.1, R33.1
unnamed: J35.1, R34.1
unnamed: J36.1, R35.1
unnamed: J37.1, R36.1
unnamed: J38.1, R37.1
unnamed: J39.1, R38.1
unnamed: J40.1, R39.1
unnamed: J41.1, R40.1
unnamed: J42.1, R41.1
unnamed: J43.1, R42.1
unnamed: J44.1, R43.1
unnamed: J45.1, R44.1
unnamed: J46.1, R45.1
unnamed: J47.1, R46.1
unnamed: J48.1, R47.1
unnamed: J49.1, R48.1
unnamed: J50.1, R49.1
unnamed: J51.1, R50.1
unnamed: J52.1, R51.1
unnamed: J53.1, R52.1
unnamed: J54.1, R53.1
unnamed: J55.1, R54.1
unnamed: J56.1, R55.1
unnamed: J57.1, R56.1
unnamed: J58.1, R57.1
unnamed: J59.1, R58.1
unnamed: J60.1, R59.1
unnamed: J61.1, R60.1
unnamed: J62.1, R61.1
unnamed: J63.1, R62.1
unnamed: J64.1, R63.1
unnamed: J65.1, R64.1
unnamed: R1.2, U1.15 (QA)
unnamed: R2.2, U1.1 (QB)
unnamed: R3.2, U1.2 (QC)
unnamed: R4.2, U1.3 (QD)
unnamed: R5.2, U1.4 (QE)
unnamed: R6.2, U1.5 (QF)
unnamed: R7.2, U1.6 (QG)
unnamed: R8.2, U1.7 (QH)
unnamed: R9.2, U2.15 (QA)
unnamed: R10.2, U2.1 (QB)
unnamed: R11.2, U2.2 (QC)
unnamed: R12.2, U2.3 (QD)
unnamed: R13.2, U2.4 (QE)
unnamed: R14.2, U2.5 (QF)
unnamed: R15.2, U2.6 (QG)
unnamed: R16.2, U2.7 (QH)
unnamed: R17.2, U3.15 (QA)
unnamed: R18.2, U3.1 (QB)
unnamed: R19.2, U3.2 (QC)
unnamed: R20.2, U3.3 (QD)
unnamed: R21.2, U3.4 (QE)
unnamed: R22.2, U3.5 (QF)
unnamed: R23.2, U3.6 (QG)
unnamed: R24.2, U3.7 (QH)
unnamed: R25.2, U4.15 (QA)
unnamed: R26.2, U4.1 (QB)
unnamed: R27.2, U4.2 (QC)
unnamed: R28.2, U4.3 (QD)
unnamed: R29.2, U4.4 (QE)
unnamed: R30.2, U4.5 (QF)
unnamed: R31.2, U4.6 (QG)
unnamed: R32.2, U4.7 (QH)
unnamed: R33.2, U5.15 (QA)
unnamed: R34.2, U5.1 (QB)
unnamed: R35.2, U5.2 (QC)
unnamed: R36.2, U5.3 (QD)
unnamed: R37.2, U5.4 (QE)
unnamed: R38.2, U5.5 (QF)
unnamed: R39.2, U5.6 (QG)
unnamed: R40.2, U5.7 (QH)
unnamed: R41.2, U6.15 (QA)
unnamed: R42.2, U6.1 (QB)
unnamed: R43.2, U6.2 (QC)
unnamed: R44.2, U6.3 (QD)
unnamed: R45.2, U6.4 (QE)
unnamed: R46.2, U6.5 (QF)
unnamed: R47.2, U6.6 (QG)
unnamed: R48.2, U6.7 (QH)
unnamed: R49.2, U7.15 (QA)
unnamed: R50.2, U7.1 (QB)
unnamed: R51.2, U7.2 (QC)
unnamed: R52.2, U7.3 (QD)
unnamed: R53.2, U7.4 (QE)
unnamed: R54.2, U7.5 (QF)
unnamed: R55.2, U7.6 (QG)
unnamed: R56.2, U7.7 (QH)
unnamed: R57.2, U8.15 (QA)
unnamed: R58.2, U8.1 (QB)
unnamed: R59.2, U8.2 (QC)
unnamed: R60.2, U8.3 (QD)
unnamed: R61.2, U8.4 (QE)
unnamed: R62.2, U8.5 (QF)
unnamed: R63.2, U8.6 (QG)
unnamed: R64.2, U8.7 (QH)
unnamed: U1.9 (QH*), U2.14 (SER)
unnamed: U2.9 (QH*), U3.14 (SER)
unnamed: U3.9 (QH*), U4.14 (SER)
unnamed: U4.9 (QH*), U5.14 (SER)
unnamed: U5.9 (QH*), U6.14 (SER)
unnamed: U6.9 (QH*), U7.14 (SER)
unnamed: U7.9 (QH*), U8.14 (SER)

Notes on the sheet:
Holes
Shield for Arduino Nano

Board: 2 copper layers, 182.8 x 160.5 mm, 176 parts (111 on the bottom side), 157 nets.

## Commit log

2022-11-04 fix u1
2022-11-04 fix 回路図
2022-11-06 fix うへへ
2022-11-07 fix aaa
2022-11-07 fix test
